# Keil uVision project third_ver.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: third_ver
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c InitCU.c Timer0.c Timer1.c Timer2.c Timer3.c Timer4.c Display.c Delays.c Buttons.c DeviceParameters.c Menu.c FontDisplay.c BigFont.c MiddleFont.c Indication.c SFRPage.c Sound.c UART0.c
